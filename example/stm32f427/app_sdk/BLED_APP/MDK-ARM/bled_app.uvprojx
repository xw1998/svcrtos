# Keil uVision project bled_app.uvprojx, settings and files
target BLED_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: bled_app +hex
  BeforeMake: python ..\..\..\..\..\tools\gen_scatter.py --target app --output ..\..\..\..\..\build\app.sct
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Src;..\..\..\..\..\kernelsrc\sdk\app_sdk;..\..\..\..\..\kernelsrc\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\..\build\app.sct
  group App
    ../Src/: bled_app.c
  group App_SDK
    ../../../../../kernelsrc/sdk/app_sdk/: svcrt_app_main.c svcrt_oslib.c svcrt_app_start.s
