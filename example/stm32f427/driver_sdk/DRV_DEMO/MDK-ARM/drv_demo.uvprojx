# Keil uVision project drv_demo.uvprojx, settings and files
target DRV_DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: drv_demo +hex
  BeforeMake: python ..\..\..\..\..\tools\gen_scatter.py --target driver --output ..\..\..\..\..\build\driver.sct
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SVCRT_DRV_USER_MODE
  c include: ..\Src;..\..\..\..\..\kernelsrc\sdk\driver_sdk;..\..\..\..\..\kernelsrc\include
  scatter file: ..\..\..\..\..\build\driver.sct
  group Driver
    ../Src/: temp_drv.c
  group Driver_SDK
    ../../../../../kernelsrc/sdk/driver_sdk/: svcrt_drv_main.c svcrt_driver_bridge.c svcrt_drv_oslib.c svcrt_drv_start.s
