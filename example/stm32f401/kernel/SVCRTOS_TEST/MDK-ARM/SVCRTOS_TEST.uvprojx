# Keil uVision project SVCRTOS_TEST.uvprojx, settings and files
target SVCRTOS_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SVCRTOS_TEST +hex
  BeforeMake: py -3 ..\..\..\..\..\tools\gen_scatter.py --target kernel --header config/stm32f401/svcrt_partition.h --output ..\..\..\..\..\build\f401_kernel.sct
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xx,SVCRT_USE_FPU=1,SVCRT_BOARD_CONFIG=\"svcrt_board_config.h\"
  c misc: -DMDK_TRACE_SWD_EXTERNAL_PLATFORM -DMDK_TRACE_USE_CONFIG_FILE -DLFS_NO_MALLOC -DLFS_NO_ASSERT -DLFS_NO_DEBUG -DLFS_NO_WARN -DLFS_NO_ERROR
  c include: ../../../../../kernelsrc/components/mdk_trace;../Core/Inc;../../../../stm32f427/kernel/SVCRTOS_TEST/Drivers/STM32F4xx_HAL_Driver/Inc;../../../../stm32f427/kernel/SVCRTOS_TEST/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../stm32f427/kernel/SVCRTOS_TEST/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../stm32f427/kernel/SVCRTOS_TEST/Drivers/CMSIS/Include;../../../../../kernelsrc/include;../../../../../kernelsrc/fs;../../../../../kernelsrc/fs/littlefs;../../../../../board/stm32f401;../../../../../config/stm32f401;../../../../../kernelsrc/shell;../../../../../kernelsrc/shell/ark_shell
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ..\..\..\..\..\build\f401_kernel.sct
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: system_stm32f4xx.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group SVCRTOS/Kernel
    ../../../../../kernelsrc/src/: svcrt_task.c svcrt_blk.c svcrt_fs.c svcrt_trace.c svcrt_dev.c svcrt_event.c svcrt_fifo.c svcrt_cfg.c svcrt_sync.c svcrt_mq.c svcrt_timer.c svcrt_fault.c svcrt_init.c svcrt_mpu.c svcrt_ptable.c svcrt_layout.c svcrt_loader.c svcrt_installer.c svcrt_log.c
    ../../../../../kernelsrc/fs/littlefs/: lfs.c lfs_util.c
    ../../../../../kernelsrc/components/mdk_trace/: mdk_trace.c mdk_trace_swd.c
  group SVCRTOS/Shell
    ../../../../../kernelsrc/shell/: platform_svcrtos.c svcrt_shell.c
    ../../../../../kernelsrc/shell/ark_shell/: ark_shell.c ark_shell_commands.c ark_shell_history.c ark_shell_line_editor.c ark_shell_autocomplete.c
  group SVCRTOS/Board
    ../../../../../board/stm32f401/: svcrt_board.c drvuart.c drvled.c drvflash.c
    ../../../../../kernelsrc/port/arm/cortex-m4/: svcrt_context.S svcrt_port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../stm32f427/kernel/SVCRTOS_TEST/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
